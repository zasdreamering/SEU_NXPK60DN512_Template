# Keil uVision project Test_Project.uvprojx, settings and files
target Test_Project (5060020::V5.06 (build 20)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Test_Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\personal function library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Doc
    ../Doc/: Readme.txt
  group User
    ../User/: main.c
  group Device
    ../personal function library/: nixie_tube.c led.c key.c interrupt.c general_function.c systick.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
